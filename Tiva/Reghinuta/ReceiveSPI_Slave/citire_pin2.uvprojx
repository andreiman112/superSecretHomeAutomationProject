# Keil uVision project citire_pin2.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: citire_pin2
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RA1
  c include: ..\TivaWare_C_Series-2.1.1.71;..\TivaWare_C_Series-2.1.1.71\driverlib\rvmdk
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group source
    ./: main.c gpio_handler.h gpio_handler.c display.c display.h timer.c timer.h adc_handler.c adc_handler.h pwm_handler.c pwm_handler.h i2c_handler.h i2c_handler.c ssi_handler_tw.c ssi_handler_tw.h
  group driverlib
    ../TivaWare_C_Series-2.1.1.71/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, Device:Startup 1.0.1
